# Keil uVision project TEST_LED.uvprojx, settings and files
target TEST_LED (6150000::V6.15::ARMCLANG)
  device: STM32F103C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEST_LED +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MEM_UNIT_BYTES,ARM_MATH_CM3,MemUnit_T=uint8_T,MATLAB_PROJECT,USE_HAL_DRIVER,STM32F103x6
  c include: ../Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;   ../Drivers/CMSIS/Include;   ../Drivers/CMSIS/Core/Include;   ../Drivers/CMSIS/DSP/Include;   ../TEST_LED/Inc;   "../../../../../../Program Files/Polyspace/R2020a/simulink/include"
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User
    ../Src/: main.c gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group MATLAB
    C:/Users/Harry/Desktop/MCU_homework/TEST_LED/TEST_LED/Src/: TEST_LED.c
    C:/Users/Harry/Desktop/MCU_homework/p_3/TEST_LED/Src/: TEST_LED.c
software components: CMSIS:CORE 5.4.0
